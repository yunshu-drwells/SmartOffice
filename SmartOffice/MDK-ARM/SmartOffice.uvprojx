# Keil uVision project SmartOffice.uvprojx, settings and files
target SmartOffice (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: StemWin_Port_FreeRTOS +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,USE_HAL_DRIVER,STM32F407xx,DATA_IN_ExtSRAM
  c include: ../Inc;                      ../Drivers/STM32F4xx_HAL_Driver/Inc;                      ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;                      ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;                      ../Drivers/CMSIS/Include;                      ../Middlewares/Third_Party/FreeRTOS/Source/include;                      ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;                      ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;                      ../Middlewares/Third_Party/LwIP/src/include;                      ../Middlewares/Third_Party/LwIP/system;                      ../Middlewares/Third_Party/LwIP/src/include/netif/ppp;                      ../Middlewares/Third_Party/LwIP/src/include/lwip;                      ../Middlewares/Third_Party/LwIP/src/include/lwip/apps;                      ../Middlewares/Third_Party/LwIP/src/include/lwip/priv;                      ../Middlewares/Third_Party/LwIP/src/include/lwip/prot;                      ../Middlewares/Third_Party/LwIP/src/include/netif;                      ../Middlewares/Third_Party/LwIP/system/arch;                      ..\Middlewares\STemWin\Config;                      ..\Middlewares\STemWin\inc;                      ..\Middlewares\STemWin\Application;               ../Middlewares/Third_Party/FatFs/src
  asm include: ..\\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x68000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: mymalloc.c sram.c delay.c lcd.c ctiic.c ft5206.c gt9xxx.c touch.c norflash.c dht11.c adc3.c lsens.c fonts.c icon.c esp8266.c esp8266_web.c main.c gpio.c adc.c crc.c dma.c bsp_driver_sd.c sd_diskio.c fatfs.c user_diskio.c freertos.c fsmc.c i2c.c lwip.c ethernetif.c sdio.c spi.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_eth.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_crc.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_sram.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sd.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_5.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: auth.c ccp.c chap_ms.c chap-md5.c chap-new.c demand.c eap.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c ecp.c
    ../Middlewares/Third_Party/LwIP/src/netif/: ethernet.c slipif.c lowpan6.c
    ../Middlewares/Third_Party/LwIP/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../Middlewares/Third_Party/LwIP/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
    ../Middlewares/Third_Party/LwIP/src/apps/mqtt/: mqtt.c
  group Middlewares/STemWin
    ../Middlewares/STemWin/Config/: GUIConf.c GUIDRV_Template.c LCDConf_FlexColor_Template.c
    ../Middlewares/STemWin/OS/: GUI_X_OS.c
    ../Middlewares/STemWin/Lib/: STemWin_CM4_OS_wc16_ot.a
    ../Src/: GUI_X_Touch_Analog.c
    ../Middlewares/STemWin/Application/font/: font.c
    ../Middlewares/STemWin/Application/: mainTask.c Window1DLG.c Window0DLG.c
    ../Middlewares/STemWin/Application/sub/: AlarmDLG.c BrightnesssDLG.c FanDLG.c HumidityDLG.c LightingMasterDLG.c SpotlightDLG.c TemperatureDLG.c TurnOffDLG.c MagnetismLock.c NetworkInfoDLG.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c cc936.c
